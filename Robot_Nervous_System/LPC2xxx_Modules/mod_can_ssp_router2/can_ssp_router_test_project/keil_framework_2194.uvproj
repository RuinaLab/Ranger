# Keil uVision project keil_framework_2194.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2194/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Startup Code
    ./src/: Startup.s
  group Board Code
    ./src/: main.c hardware_setup.c software_setup.c
  group Module Code
    ../../mod_heartbeat/: heartbeat.c
    ../../mod_scheduler/: scheduler.c
    ../: can_ssp_router.c
    ../../mod_can/: can_types.c can_isr.c can_ring.c can_rx.c can_tx.c
    ../../mod_error/: error.c
target MCB2100 Flash (ARM-ADS)
  device: LPC2194/01 NXP (founded by Philips)
  cpu: as above
  output: keil_framework_2194 +hex
  c flags: Optim=2 oTime=1 wLevel=2
  c include: ..\;.\src;..\..\..\LPC2xxx_Modules
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x3000
target MCB2100 RAM (ARM-ADS)
  device: LPC2194/01 NXP (founded by Philips)
  cpu: as above
  output: keil_framework_2194 +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x3000
